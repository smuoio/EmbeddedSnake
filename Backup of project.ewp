# IAR project Backup of project.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2378 NXP LPC2378
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_LPC_2378_SK
  ICCARM.CCIncludePath2: ; app\; board\; drivers\headers; config\; timer0\; LowLevelInit\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: LCD_Demo.out
  ILINK.IlinkIcfFile: config\LPC2378_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ; app\; board\; modules\
configuration SRAM Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ; app\; board\; modules\; LowLevelInit\; Timer0\
  ILINK.IlinkIcfFile: config\LPC2378_Ram.icf
  group (top)
    LowLevelInit/: LowLevelInit.c
    Timer0/: Timer0.c
  group Fonts
    Drivers/source/Fonts/: Terminal_18_24x12.c Terminal_6_8x6.c Terminal_9_12x6.c
  group Modules
    Drivers/source/: Accelerometer.c ADC.c appBoard.c Buttons.c DAC.c drv_glcd.c glcd_ll.c GPIO.c iar_logo.c LEDs.c Potentiometer.c
    modules/: drv_glcd_cnfg.h
    app/: main.c
